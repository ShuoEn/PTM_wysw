# Keil uVision project project.uvproj, settings and files
target Target 1 (ARM-GNU)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: project +hex
  AfterMake: proj_objdump.cmd $L@L.elf $L@L.lss
  group Source Group 1
    ./: dcc_stdio.c main.c stm32f4xx_it.c system_stm32f4xx.c startup_stm32f4xx.S syscalls.c term_io.c usbd_usr.c usb_bsp.c usbd_cdc_vcp.c usbd_desc.c
    ./Libraries/STM32F4-Discovery/: stm32f4_discovery.c
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_syscfg.c misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_exti.c
  group various
    ./: Makefile STM32F4xx_1024k_flash.ld readme_mthomas.txt
    ./FLASH_RUN/: project.lss
  group stusb
    ./Libraries/STM32_USB_Device_Library/Core/src/: usbd_req.c usbd_core.c usbd_ioreq.c
    ./Libraries/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
    ./Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
